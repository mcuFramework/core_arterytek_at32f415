# Keil uVision project core_at32f415.uvprojx, settings and files
target core_at32f415_lib (6150000::V6.15::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: mcuf_at32f415 (library)
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\src\main;.\ref\mcuf\src\main;.\ref\bsp_arterytek_at32f415\src\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./src/main/: core_at32f415.h
  group main/core_arterytek_at32f415
    ./src/main/core_arterytek_at32f415/: isr_at32f415.h isr_at32f415_timer.cpp isr_at32f415_timer.h
  group main/core
    ./src/main/core/: core.h
  group main/core/arterytek
    ./src/main/core/arterytek/: arterytek.h
  group main/core/arterytek/at32f415
    ./src/main/core/arterytek/at32f415/: at32f415.h Core.cpp Core.hpp CoreAFIO.cpp CoreAFIO.hpp CoreEntitySPI.cpp CoreEntitySPI.hpp CoreGPIO.cpp CoreGPIO.hpp CoreIIC.cpp CoreIIC.hpp CorePin.cpp CorePin.hpp CoreSPI.cpp CoreSPI.hpp CoreTimer.cpp CoreTimer.hpp CoreUSART.cpp CoreUSART.hpp
  group main/core/arterytek/at32f415/ctrl
    ./src/main/core/arterytek/at32f415/ctrl/: CtrlInterrupt.cpp CtrlInterrupt.hpp
  group resources
    ./src/resources/: mcuf_at32f415_startup.s mcuf_at32f415_system.c mcuf_at32f415_interrupt_priority.c mcuf_at32f415_interrupt_service.c
  group test/start
    ./src/test/start/: main_cpp.cpp start.cpp loop.cpp
  group ref
    ./ref/mcuf/target/: mcuf_m4.lib
    ./ref/bsp_at32f415/target/: bsp_at32f415.lib
target core_at32f415_debug (6150000::V6.15::ARMCLANG)
  device: AT32F415R8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: core_at32f415
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYSCLK_FREQ_144MHz_HSI, DEBUG
  c include: .\src\lowlevel;.\src\main;.\ref\mcuf\src\main;.\ref\bsp_at32f415\src\lowlevel
  asm include: ..\framework
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
