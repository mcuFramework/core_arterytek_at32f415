# Keil uVision project core.uvprojx, settings and files
target core (6160000::V6.16::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: core (library)
  AfterMake: .keil\copy.bat core.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415RBT7
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group arm
    ./arm/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iar.h cmsis_iccarm.h cmsis_version.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h mpu_armv7.h mpu_armv8.h package-info.h pmu_armv8.h
  group bsp
    ./bsp/: at32f415.h at32f415_adc.c at32f415_adc.h at32f415_can.c at32f415_can.h at32f415_cmp.c at32f415_cmp.h at32f415_conf.h at32f415_conf_template.h at32f415_crc.c at32f415_crc.h at32f415_crm.c at32f415_crm.h at32f415_debug.c at32f415_debug.h at32f415_def.h at32f415_dma.c at32f415_dma.h at32f415_ertc.c at32f415_ertc.h at32f415_exint.c at32f415_exint.h at32f415_flash.c at32f415_flash.h at32f415_gpio.c at32f415_gpio.h at32f415_i2c.c at32f415_i2c.h at32f415_misc.c at32f415_misc.h at32f415_pwc.c at32f415_pwc.h at32f415_sdio.c at32f415_sdio.h at32f415_spi.c at32f415_spi.h at32f415_tmr.c at32f415_tmr.h at32f415_usart.c at32f415_usart.h at32f415_usb.c at32f415_usb.h at32f415_wdt.c at32f415_wdt.h at32f415_wwdt.c at32f415_wwdt.h package-info.h system_at32f415.c system_at32f415.h
  group bsp/middlewares
    ./bsp/middlewares/: custom_hid_class.c custom_hid_class.h custom_hid_desc.c custom_hid_desc.h package-info.h usb_conf.h usb_core.c usb_core.h usb_std.h usbd_core.c usbd_core.h usbd_int.c usbd_int.h usbd_sdr.c usbd_sdr.h
  group core
    ./core/: Core.cpp Core.h CoreAnalogInputPin.cpp CoreAnalogInputPin.h CoreAnalogInputPort.cpp CoreAnalogInputPort.h CoreEdgeTrigger.cpp CoreEdgeTrigger.h CoreEdgeTriggerReg.h CoreFlashStorage.cpp CoreFlashStorage.h CoreGeneralPin.cpp CoreGeneralPin.h CoreGeneralPort.cpp CoreGeneralPort.h CoreGeneralPortReg.h CoreHumanInterfaceDevices.cpp CoreHumanInterfaceDevices.h CoreInterrupt.cpp CoreInterrupt.h CoreIomux.cpp CoreIomux.h CorePulseWidthPin.cpp CorePulseWidthPin.h CorePulseWidthPort.cpp CorePulseWidthPort.h CorePulseWidthPortSoft.cpp CorePulseWidthPortSoft.h CorePulseWidthReg.h CoreSerialBus.cpp CoreSerialBus.h CoreSerialBusConfig.h CoreSerialBusErrorCode.h CoreSerialBusErrorEvent.cpp CoreSerialBusErrorEvent.h CoreSerialBusReg.h CoreSerialBusSlave.cpp CoreSerialBusSlave.h CoreSerialBusSlaveErrorEvent.cpp CoreSerialBusSlaveErrorEvent.h CoreSerialPeriph.cpp CoreSerialPeriph.h CoreSerialPeriphConfig.h CoreSerialPeriphPacket.h CoreSerialPeriphReg.h CoreSerialPort.cpp CoreSerialPort.h CoreSerialPortConfig.h CoreSerialPortReg.h CoreTimer.cpp CoreTimer.h CoreTimerReg.h InputMode.h OutputMode.h package-info.h
  group resources
    ./resources/: core_arterytek_interrupt.cpp core_arterytek_interrupt_priority.c core_arterytek_startup.s
