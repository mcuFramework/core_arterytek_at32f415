# Keil uVision project core_arterytek_at32f415.uvprojx, settings and files
target core_arterytek_at32f415_lib (6160000::V6.16::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: core_arterytek_at32f415 (library)
  AfterMake: .keil\copy.bat core_arterytek_at32f415.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415RBT7
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group resources
    ./resources/: core_arterytek_interrupt.cpp core_arterytek_interrupt_priority.c core_arterytek_startup.s
  group src
    ./: Core.cpp Core.h CoreAnalogInputPin.cpp CoreAnalogInputPin.h CoreAnalogInputPort.cpp CoreAnalogInputPort.h CoreEdgeTrigger.cpp CoreEdgeTrigger.h CoreEdgeTriggerReg.h CoreFlashStorage.cpp CoreFlashStorage.h CoreGeneralPin.cpp CoreGeneralPin.h CoreGeneralPort.cpp CoreGeneralPort.h CoreGeneralPortReg.h CoreHumanInterfaceDevices.cpp CoreHumanInterfaceDevices.h CoreInterrupt.cpp CoreInterrupt.h CoreIomux.cpp CoreIomux.h CorePulseWidthPin.cpp CorePulseWidthPin.h CorePulseWidthPort.cpp CorePulseWidthPort.h CorePulseWidthPortSoft.cpp CorePulseWidthPortSoft.h CorePulseWidthReg.h CoreSerialBus.cpp CoreSerialBus.h CoreSerialBusConfig.h CoreSerialBusErrorCode.h CoreSerialBusErrorEvent.cpp CoreSerialBusErrorEvent.h CoreSerialBusReg.h CoreSerialBusSlave.cpp CoreSerialBusSlave.h CoreSerialBusSlaveErrorEvent.cpp CoreSerialBusSlaveErrorEvent.h CoreSerialPeriph.cpp CoreSerialPeriph.h CoreSerialPeriphConfig.h CoreSerialPeriphPacket.h CoreSerialPeriphReg.h CoreSerialPort.cpp CoreSerialPort.h CoreSerialPortConfig.h CoreSerialPortReg.h CoreTimer.cpp CoreTimer.h CoreTimerReg.h InputMode.h OutputMode.h package-info.h
